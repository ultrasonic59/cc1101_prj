# IAR project Backup (1) of radio_extender.ewp, settings and files
configuration radio_extender (ARM, debug)
  General.OGChipSelectEditMenu: AT32F415RCT7_v2 ArteryTek -AT32F415RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; TX_INCLUDE_USER_DEFINE_FILE; AT_START_F415_V1; AT32F415RCT7; UX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCIncludePath2: inc; libraries\cmsis\cm4\device_support; libraries\drivers\inc; at32f415_board; libraries\cmsis\cm4\core_support; ..\common\threadx\common\inc; ..\common\threadx\ports\cortex_m3\iar\inc; usb\usb_drivers\inc; usb\usbd_class\cdc; board; ..\common\inc; src; src\calc_crc; src\pc_cmd; ..\common\threadx\common\inc; ..\common\threadx\ports\cortex_m3\iar\inc; ..\common\modbus; ..\common\calc_crc; ..\common\circ_buf; src; ..\common\usbx\common\core\inc; ..\common\usbx\common\usbx_device_classes\inc; ..\common\usbx\ports\cortex_m4\iar\inc; src\usbx
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: inc; src
  OBJCOPY.OOCOutputFile: freertos_demo.hex
  ILINK.IlinkOutputFile: emul_line.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    board/: bat_brd.c bat_brd.h uart.c uart.h
    src/: retarget.c
  group cmsis
    libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f415.s
    libraries/cmsis/cm4/device_support/: system_at32f415.c
  group firmware
    libraries/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group threadx
    ../common/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
    ../common/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set_notify.c tx_event_flags_set.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send_notify.c tx_queue_send.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put_notify.c tx_semaphore_put.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice_change.c tx_thread_time_slice.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set_notify.c txe_event_flags_set.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send_notify.c txe_queue_send.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put_notify.c txe_semaphore_put.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../common/threadx/ports/cortex_m3/iar/src/: tx_misra.s tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s tx_iar.c
    src/: tx_initialize_low_level.s tx_user.h
    ../common/threadx/ports/cortex_m3/iar/inc/: tx_port.h
  group usbd_class
    usb/usbd_class/cdc/: cdc_class.c cdc_class.h cdc_desc.c cdc_desc.h
  group usbd_driver
    usb/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group user
    src/: at32f415_clock.c at32f415_int.c at32f415xx.h cc1101.c gpio_init.c tx_application.c tx_systick_config.c main.c my_tasks.c protocol.c cobs.c usb_thr.c
  group usbx
    src/usbx/: ux_dcd_at32.c usbd_usbx_class.c usbx_app.c usbx_cdc.c usbx_descriptors.c
    ../common/usbx/common/core/src/: ux_system_initialize.c ux_system_uninitialize.c ux_system_error_handler.c ux_system_tasks_run.c ux_device_stack_initialize.c ux_device_stack_uninitialize.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_configuration_set.c ux_device_stack_configuration_get.c ux_device_stack_interface_set.c ux_device_stack_interface_get.c ux_device_stack_interface_start.c ux_device_stack_interface_delete.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_set_feature.c ux_device_stack_clear_feature.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_transfer_abort.c ux_device_stack_tasks_run.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_transfer_all_request_abort.c ux_utility_memory_allocate.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_free.c ux_utility_memory_copy.c ux_utility_memory_set.c ux_utility_memory_compare.c ux_utility_memory_free_block_best_get.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_on.c ux_utility_mutex_off.c ux_utility_delay_ms.c ux_utility_descriptor_parse.c ux_utility_descriptor_pack.c ux_utility_long_get.c ux_utility_long_put.c ux_utility_short_get.c ux_utility_short_put.c ux_utility_string_length_check.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_resume.c ux_utility_thread_suspend.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c
    ../common/usbx/common/usbx_device_classes/src/: ux_device_class_cdc_acm_entry.c ux_device_class_cdc_acm_initialize.c ux_device_class_cdc_acm_activate.c ux_device_class_cdc_acm_deactivate.c ux_device_class_cdc_acm_control_request.c ux_device_class_cdc_acm_read.c ux_device_class_cdc_acm_write.c ux_device_class_cdc_acm_bulkin_thread.c ux_device_class_cdc_acm_bulkout_thread.c ux_device_class_cdc_acm_tasks_run.c ux_device_class_cdc_acm_unitialize.c ux_device_class_cdc_acm_ioctl.c
